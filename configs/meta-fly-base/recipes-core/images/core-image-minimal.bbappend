# Base image customization hook for Mellow Fly-Pi-lite2.1 (fly-h3)
